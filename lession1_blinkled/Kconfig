## lession1_blinkled/Kconfig
```kconfig
menu "Test LED Driver"

config DEMO_LED
	tristate "LED Demo"
	help
	  LED Driver IMX
endmenu
```
